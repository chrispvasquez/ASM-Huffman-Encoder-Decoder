# Keil uVision project SEMPROJ.uvproj, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: EM773 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SEMPROJ
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_EM77x.s SEMPROJ.s
